## arch/arm/configs/furnace_defconfig
```kconfig
CONFIG_LOCALVERSION="-furnace"
CONFIG_FB_MSM_MDSS_KCAL_CTRL=y
CONFIG_CPU_FREQ_GOV_INTERACTIVE=y
CONFIG_FURNACE_BOOTMODE=y
```
